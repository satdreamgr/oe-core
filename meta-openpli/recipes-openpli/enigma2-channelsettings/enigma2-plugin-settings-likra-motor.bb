DESCRIPTION = "Likra Motor channel settings"

SETTINGS_FILENAME = "likra.rotor"

include sdg-settings.inc
