DESCRIPTION = "Vhannibal Motor channel settings"

SETTINGS_FILENAME = "vhannibal.motor"

include sdg-settings.inc
