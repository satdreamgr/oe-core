SUMMARY = "ciefp enigma2 settings Motor 75E to 34W and VOD"

SETTINGS_FILENAME = "ciefp-E2-motor-75E-34W"

include ciefp.inc
