SUMMARY = "ciefp enigma2 settings 19E 16E"

SETTINGS_FILENAME = "ciefp-E2-2satB-19E-16E"

include ciefp.inc
