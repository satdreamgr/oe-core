DESCRIPTION = "Likra Rotor channel settings"

SETTINGS_FILENAME = "likra.rotor"

include sdg-settings.inc
