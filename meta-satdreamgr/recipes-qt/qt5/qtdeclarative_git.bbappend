INSANE_SKIP_${PN} += "file-rdeps"
INSANE_SKIP_${PN}-tools += "file-rdeps"

PACKAGE_ARCH := "${MACHINE_ARCH}"
