SUMMARY = "A very fast JSON encoder/decoder for Python"
HOMEPAGE = "https://github.com/AGProjects/python-cjson"

LICENSE = "LGPLv2+"
LIC_FILES_CHKSUM = "file://LICENSE;md5=0816bf71e8b244e6de5618a54522e845"

SRC_URI[md5sum] = "9dcafae7c6ff38efdffeabad037811d0"
SRC_URI[sha256sum] = "52db2745264624768bfd9b604acb38f631bde5c2ec9b23861677d747e4558626"

PYPI_PACKAGE = "python-cjson"
inherit pypi setuptools siteinfo
