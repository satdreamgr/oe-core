require dab-cmdline-sdgradio.inc

EXTRA_OECMAKE = "-DAAC_OUT=ON -DRTL_TCP=ON -DCMAKE_INSTALL_PREFIX=/usr/bin"
